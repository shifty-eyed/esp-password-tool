## sdkconfig.defaults
```kconfig
CONFIG_BSP_LCD_DRAW_BUF_HEIGHT=40
CONFIG_BSP_I2C_CLK_SPEED_HZ=400000
CONFIG_ESP_LCD_TOUCH_MAX_POINTS=1
```
